# IAR project MSC_Host.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32C113xB GD GD32C113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32C11X
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\fat_fs\inc; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\host\core\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\host\class\msc\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\common; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\class\msc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MSC_Host.srec
  ILINK.IlinkOutputFile: Project.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32c113v_lcd_eval.c gd32c11x_it.c gd32c11x_usb_hw.c lcd_font.c lcd_log.c main.c usbh_usr.c
  group CMSIS
    ../../../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32C11x_EVAL
    ../../../../../Utilities/: gd32c113v_eval.c
  group GD32C11x_Peripherals
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_gpio.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_timer.c gd32c11x_usart.c
  group Startup
    ../../../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/IAR/: startup_gd32c11x.s
  group USB_Class
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
