# Keil uVision project HID_keyborad.uvproj, settings and files
target USBFS_DHID (ARM-ADS)
  device: GD32C113VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32C11X
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include;..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include;..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\device\core\Include;..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\device\class\hid\Include;..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\common;..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c gd32c11x_hw.c gd32c11x_it.c hid_keyboard_itf.c
  group CMSIS
    ../../../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group GD32C11x_StdPeriph_Driver
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_ctc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_gpio.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_timer.c gd32c11x_usart.c
  group GD32C11x_EVAL
    ../../../../../Utilities/: gd32c113v_eval.c
  group USB_Driver
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
  group Doc
    ../: readme.txt
