# IAR project HID_keyboard.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32C113xB GD GD32C113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32C11X
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\device\core\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\common; ..\..\..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\class\hid
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_keyboard.srec
  ILINK.IlinkOutputFile: Project.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32c11x_hw.c gd32c11x_it.c hid_keyboard_itf.c
  group CMSIS
    ../../../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group Doc
    ../: readme.txt
  group GD32C11x_EVAL
    ../../../../../Utilities/: gd32c113v_eval.c
  group GD32C11x_Peripherals
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_ctc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_gpio.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_timer.c gd32c11x_usart.c
  group Startup
    ../../../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/IAR/: startup_gd32c11x.s
  group USB_Class
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
