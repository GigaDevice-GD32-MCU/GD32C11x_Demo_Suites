# Keil uVision project GD32C113V_EVAL.uvproj, settings and files
target GD32C113V_EVAL (ARM-ADS)
  device: GD32C113VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C11X
  c include: ..\..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include;..\..\..\..\GD32C11x_Firmware_Library\CMSIS;..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include;..\..\..\Utilities;..\..\19_RTC_Calendar;..\Soft_Drive;..\..\..\Utilities\LCD_Commom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32c11x_it.c systick.c
    ../Soft_Drive/: rtc.c
  group CMSIS
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group GD32C11x_Peripherals
    ../../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_adc.c gd32c11x_bkp.c gd32c11x_can.c gd32c11x_crc.c gd32c11x_ctc.c gd32c11x_dac.c gd32c11x_dbg.c gd32c11x_dma.c gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_fwdgt.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_rtc.c gd32c11x_spi.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_wwdgt.c
  group GD32C11x_EVAL
    ../../../Utilities/: gd32c113v_eval.c gd32c113v_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group Startup
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
  group Doc
    ../: readme.txt
