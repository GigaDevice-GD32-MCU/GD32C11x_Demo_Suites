# IAR project GD32C113V_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32C113xB GD GD32C113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32C11X
  ICCARM.CCIncludePath2: ..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include; ..\..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include; ..; ..\..\..\Utilities; ..\Soft_Drive; ..\..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32c11x_it.c main.c systick.c
    ../Soft_Drive/: rtc.c
  group CMSIS
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group Doc
    ../: readme.txt
  group GD32C11x_EVAL
    ../../../Utilities/: gd32c113v_eval.c gd32c113v_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group GD32C11x_Peripherals
    ../../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_adc.c gd32c11x_bkp.c gd32c11x_can.c gd32c11x_crc.c gd32c11x_ctc.c gd32c11x_dac.c gd32c11x_dbg.c gd32c11x_dma.c gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_fwdgt.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_rtc.c gd32c11x_spi.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_wwdgt.c
  group Startup
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/IAR/: startup_gd32c11x.s
