# Keil uVision project msc_udisk.uvproj, settings and files
target msc_udisk (ARM-ADS)
  device: GD32C113CB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: msc_udisk +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32C11X
  c misc: --c99
  c include: ..\inc;..\..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include;..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include;..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\driver\Include;..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\device\core\Include;..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\device\class\msc\Include;..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\common;..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\class\msc;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c flash_msd.c usbd_storage_msd.c gd32c11x_hw.c gd32c11x_it.c
  group CMSIS
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group GD32C10x_StdPeriph_Driver
    ../../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_ctc.c gd32c11x_dma.c gd32c11x_fmc.c gd32c11x_gpio.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_exti.c
  group GD32C10x_EVAL
    ../../../Utilities/: gd32c113c_start.c
  group USB_Drivers
    ../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group Startup
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
  group Doc
    ../: readme.txt
