# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32C113xB GD GD32C113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32C11X
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities; ..\..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include; ..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include; ..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\driver\Include; ..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\host\class\hid\Include; ..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\host\core\Include; ..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\class\hid; ..\..\..\..\GD32C11x_Firmware_Library\GD32C11x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32c11x_it.c gd32c11x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group Doc
    ../: readme.txt
  group GD32C11x_EVAL
    ../../../Utilities/: gd32c113c_start.c
  group GD32C11x_Peripherals
    ../../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_gpio.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_timer.c gd32c11x_usart.c
  group Startup
    ../../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/IAR/: startup_gd32c11x.s
  group USB_Class
    ../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Drivers
    ../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../GD32C11x_Firmware_Library/GD32C11x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
